# IAR project Project.ewp, settings and files
configuration GD32F130_150 (ARM, debug)
  General.OGChipSelectEditMenu: GD32F150x8 GD GD32F150x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F130_150
  ICCARM.CCIncludePath2: ..; ..\..\Firmware\CMSIS; ..\..\Firmware\Peripherals\inc; ..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32F170_190 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F190xB GD GD32F190xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F170_190
  group Application
    ../: gd32f1x0_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/: system_gd32f1x0.c
  group GD32F1x0_EVAL
    ../../Utilities/: gd32f1x0_eval.c
  group GD32F1x0_Peripherals
    ../../Firmware/Peripherals/src/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_iwdg.c gd32f1x0_lcd.c gd32f1x0_mcudbg.c gd32f1x0_misc.c gd32f1x0_opamp.c gd32f1x0_pwr.c gd32f1x0_rcc.c gd32f1x0_rtc.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdg.c
  group Startup
    ../../Firmware/CMSIS/IAR/: startup_gd32f1x0.s
